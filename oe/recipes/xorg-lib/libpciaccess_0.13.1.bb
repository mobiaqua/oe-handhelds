require xorg-lib-common.inc
DEPENDS += "xproto virtual/libx11"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "399a419ac6a54f0fc07c69c9bdf452dc"
SRC_URI[archive.sha256sum] = "27ab68f645691a4ca258dcc9d131040586e134f9233ce079794496f6264da084"
