require xorg-app-common.inc
DESCRIPTION = "a utility to configure and test XInput devices"
DEPENDS += " libxi"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d2459d35b4e0b41ded26a1d1159b7ac6"
SRC_URI[archive.sha256sum] = "4ab007d952c76665603bcb82ceb15fd3929d10faf0580fc4873ac16f5f63847e"
