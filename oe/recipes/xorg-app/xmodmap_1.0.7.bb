require xorg-app-common.inc
DESCRIPTION = "utility for modifying keymaps and pointer button mappings in X"
LICENSE = "MIT"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "d9b65f6881afe0d6d9863b30e1081bde"
SRC_URI[archive.sha256sum] = "ef22ede9c4a3c720da539292c6911515a8408e618e0dec6aa2196ee2153de4b5"
