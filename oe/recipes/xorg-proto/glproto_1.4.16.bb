require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.1"

SRC_URI[archive.md5sum] = "3847963c1b88fd04a030b932b0aece07"
SRC_URI[archive.sha256sum] = "54dd663a7f5ed702f2ff035b79edf770c2f850867ac0d55742f696bfc8b2598d"
