require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "ce4d0b05675968e4c83e003cc809660d"
SRC_URI[archive.sha256sum] = "85c42e8c66a55318ddaf2ce5727beacb25cb1f8555229f778cd1da86478209cf"

CONFLICTS = "randrext"
