require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1b4e5dede5ea51906f1530ca1e21d216"
SRC_URI[archive.sha256sum] = "a777548d2e92aa259f1528de3c4a36d15e07a4650d0976573a8e2ff5437e7370"

CONFLICTS = "recordext"
