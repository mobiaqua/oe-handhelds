require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "1a05fb01fa1d5198894c931cf925c025"
SRC_URI[archive.sha256sum] = "462116ab44e41d8121bfde947321950370b285a5316612b8fce8334d50751b1e"

