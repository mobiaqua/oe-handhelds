require xorg-proto-common.inc
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "cfdb57dae221b71b2703f8e2980eaaf4"
SRC_URI[archive.sha256sum] = "3c66003a6bdeb0f70932a9ed3cf57cc554234154378d301e0c5cfa189d8f6818"

CONFLICTS = "resourceext"
