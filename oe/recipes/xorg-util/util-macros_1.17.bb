require util-macros.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "e162e8921cd08c50bf17b9de5131b3f1"
SRC_URI[archive.sha256sum] = "a7de22d6828b2a4469d32b4744ac2fe9103fcb85e72dd70794ef77f188946371"
