require makedepend.inc
PR = "${INC_PR}.0"
SRC_URI[archive.md5sum] = "bf1c54028427829c9c3193bef710dbee"
SRC_URI[archive.sha256sum] = "f53b8ce5dec02a05f8994036a8ebac485a96324143ff2382e29578fdc096b04f"
