UBOOT_MACHINE = "h3600_config"

require u-boot_2014.01.inc
