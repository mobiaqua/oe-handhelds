UBOOT_MACHINE = "h2200_config"

require u-boot_2014.01.inc
