require xorg-driver-video.inc
DESCRIPTION = "X.Org X server -- fbdev display driver"
PE = "1"
PR = "${INC_PR}.1"

SRC_URI[archive.md5sum] = "1d99f1dfb3f0fea077b6b61caa3dc85a"
SRC_URI[archive.sha256sum] = "ff7b037ad110040a4e2db5c84e9741125dbbaf3a08107db47760f3e11f9c4831"
