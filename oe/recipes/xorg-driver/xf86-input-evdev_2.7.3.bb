require xorg-driver-input.inc
DESCRIPTION = "X.Org X server -- evdev input driver"
PE = "1"
PR = "${INC_PR}.0"

SRC_URI[archive.md5sum] = "f68920ce2921a88b4662acc972bf3a4a"
SRC_URI[archive.sha256sum] = "eb389413602c3d28c44bbfab0477c98582f0e2f5be5f41986e58e93a033fa504"
